# Keil uVision project main.uvprojx, settings and files
target finger (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.2.0
  cpu: IRAM(0x20000000,0x5000) IROM(0x08000000,0x10000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: main +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: STM32F10X_MD,USE_STDPERIPH_DRIVER
  c include: ..\USER;..\SYSTEM\sys;..\SYSTEM\delay;..\SYSTEM\usart;..\FWLIB\inc;..\CORE;..\HARDWAR;..\HARDWAR\ONENET;..\NET;..\NET\CJSON;..\NET\MQTT;..\NET\net_device\inc;..\NET\onenet\inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group user
    ./: main.c stm32f10x_it.c system_stm32f10x.c
  group fwlib
    ../FWLIB/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
  group core
    ../CORE/: core_cm3.c startup_stm32f10x_md.s
  group system
    ../SYSTEM/delay/: delay.c
    ../SYSTEM/sys/: sys.c
    ../SYSTEM/usart/: usart.c usart.h
  group hardware
    ../HARDWAR/: OLED.C IO_Init.c ds18b20.c ina226.c timer.c bsp_adc.c modbus.c
  group Net_device
    ../NET/net_device/src/: esp8266.c
    ../NET/net_device/inc/: esp8266.h
  group OneNet
    ../NET/onenet/src/: base64.c hmac_sha1.c onenet.c
  group Net_protocol
    ../NET/MQTT/: MqttKit.c
  group CJSON
    ../NET/CJSON/: cJSON.c
